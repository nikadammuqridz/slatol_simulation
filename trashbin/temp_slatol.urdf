Commit message: tidy up

File: trashbin/temp_slatol.urdf (robot description, URDF)
Before this commit: robot slatol, 3 links, 2 joints
Links:
- link base_link: mass 0.7 -> 0.95
- link femur: mass 0.15 -> 0.025
- link tibia: mass 0.15 -> 0.025
